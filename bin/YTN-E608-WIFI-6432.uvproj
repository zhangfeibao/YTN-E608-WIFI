# Keil uVision project YTN-E608-WIFI-6432.uvproj, settings and files
target release (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MODP2
  output: YTN-E608-WIFI-6432 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src
  group comm
    ../src/: it.c main.c
    ./: startup.a51
  group BSP
    ../src/bsp/: bsp_init.c aip1944.c display.c buzzer.c ir.c humidity.c dust.c motor.c key.c
    ../src/: system.c
  group PROTOCOL
    ../src/protocol/: fifo.c protocol.c uart.c
  group FSM
    ../src/fsm/: fsm.c
    ../src/fsm/test/: state_test.c
    ../src/fsm/startup/: state_startup.c
    ../src/fsm/standby/: state_standby.c
    ../src/fsm/clock_setting/: state_clockSetting.c
    ../src/fsm/echeck/: state_echeck.c
    ../src/fsm/timer_setting/: state_timerSetting.c
    ../src/fsm/timer_fn_setting/: state_timerFnSetting.c
    ../src/fsm/timer_lookup/: state_timerLookup.c
    ../src/fsm/work/: state_work.c
